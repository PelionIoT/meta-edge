# Force the use of our own version of files, instead of the base recipe.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

