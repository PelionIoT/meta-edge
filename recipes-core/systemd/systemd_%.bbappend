SUMMARY = "adds gcrypt (libgcrypt) to systemd binary for forward secure sealing (ffs) journald"
PACKAGECONFIG:append = " gcrypt"

