# class for Edge component versions
#
# These can be used in other recipes for setting the SRC_REV.
# e.g.
# inherit edge_versions
# SRC_REV = "${EDGE_CORE_VERSION}"
#

EDGE_CORE_VERSION = "0.21.0"
PE_UTILS_VERSION = "2.3.3"
